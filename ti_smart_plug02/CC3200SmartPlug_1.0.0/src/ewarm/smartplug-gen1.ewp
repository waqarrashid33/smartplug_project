# IAR project smartplug-gen1.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; SMARTPLUG_HW
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\SmartPlugSource\; ..\SmartPlugSource\exosite\; ..\SmartPlugSource\utilities\; ..\SmartPlugSource\android\; ..\SmartPlugSource\metrology\; ..\driverlib\; ..\; ..\inc\; ..\simplelink\; ..\simplelink\Include\; ..\simplelink\Source\; ..\oslib; ..\third_party\FreeRTOS; ..\third_party\FreeRTOS\source; ..\third_party\FreeRTOS\source\include; ..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smartplug-gen1.bin
  ILINK.IlinkOutputFile: smartplug_gen1.out
  ILINK.IlinkConfigDefines: Flash=0
  ILINK.IlinkIcfFile: smartplug.icf
  ILINK.IlinkAdditionalLibs: ..\driverlib\ewarm\Release\Exe\driverlib.a; ..\simplelink\ewarm\OS\Exe\simplelink.a; ..\oslib\ewarm\free_rtos\Exe\free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: ext.out
  group (top)
    ../SmartPlugSource/android/: android_task.c
    ../SmartPlugSource/: cc3200.c clienthandler.c gpio_if.c main.c nvmem_api.c pinmux.c smartconfig.c smartplug_task.c uart_logger.c
    ../SmartPlugSource/exosite/: exosite.c exosite_hal.c exosite_meta.c exosite_task.c
    ../SmartPlugSource/metrology/: metrology.c udmadrv.c
    ./: startup_ewarm.c
    ../SmartPlugSource/utilities/: strlib.c
