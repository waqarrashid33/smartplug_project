<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\driverlib\ewarm\driverlib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\oslib\ewarm\oslib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\simplelink\ewarm\simplelink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\smartplug-gen1.ewp</path>
  </project>
  <batchBuild/>
</workspace>


