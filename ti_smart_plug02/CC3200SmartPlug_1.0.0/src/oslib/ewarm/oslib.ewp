# IAR project oslib.ewp, settings and files
configuration free_rtos (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\driverlib\; ..\..\..\inc\; ..; ..\..\third_party\FreeRTOS\source\; ..\..\third_party\FreeRTOS\source\include; ..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\third_party\FreeRTOS\source\; ..\..\third_party\FreeRTOS\source\include; ..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ILINK.IlinkOutputFile: oslib.out
  group (top)
    ../: osi_freertos.c
  group source
    ../../third_party/FreeRTOS/source/: croutine.c list.c queue.c tasks.c timers.c
  group source/portable/IAR/ARM_CM4
    ../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/: port.c portasm.s
  group source/portable/MemMang
    ../../third_party/FreeRTOS/source/portable/MemMang/: heap_3.c
