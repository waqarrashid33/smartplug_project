# IAR project simplelink.ewp, settings and files
configuration OS (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SL_FULL; ewarm; SL_PLATFORM_MULTI_THREADED
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\; ..\Source\; ..\Include\; ..\..\inc\; ..\..\driverlib; ..\..\oslib
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: simplelink.bin
  ILINK.IlinkOutputFile: simplelink.out
configuration NON_OS (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SL_FULL; ewarm
  ICCARM.CCIncludePath2: ..\; ..\source\; ..\include\; ..\..\inc\; ..\..\driverlib
  ICCARM.CCOptLevel: 1
configuration PM_Framework (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\; ..\source\; ..\include\; ..\..\inc\; ..\..\driverlib; ..\..\oslib; ..\..\middleware\driver\; ..\..\middleware\driver\hal\; ..\..\middleware\framework\pm\
  ICCARM.CCOptLevel: 1
  group (top)
    ../: cc_pal.c cc_pal_pm.c
    ../Source/: device.c driver.c flowcont.c fs.c netapp.c netcfg.c nonos.c socket.c spawn.c wlan.c
